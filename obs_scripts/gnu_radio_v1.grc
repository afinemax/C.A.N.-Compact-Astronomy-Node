options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: gain
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: RTL820T
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '30'
    freq0: c_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nchan
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: observation.dat
    type: float
    vlen: nchan
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(obs_time*samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: nbin
    type: float
    vlen: nchan
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nchan
    type: complex
  states: {}
- name: c_freq
  id: parameter
  parameters:
    type: eng_float
    value: '1420000000'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nchan
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nchan)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: nbin
  id: parameter
  parameters:
    type: intx
    value: '1000'
  states: {}
- name: nchan
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}
- name: obs_time
  id: parameter
  parameters:
    type: eng_float
    value: '60'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '2400000'
  states: {}

connections:
- [RTL820T, '0', blocks_head_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
